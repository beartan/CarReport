# Keil uVision project CarDemo.uvproj, settings and files
target CarDemo (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CarDemo +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\src\bsp;..\src\dev;..\src\lib\inc;..\src\pro;..\src\user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp
    ../src/bsp/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./: startup_stm32f10x_hd.s
  group lib
    ../src/lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group dev
    ../src/dev/: Core.c Iwdg.c SysInit.c SysTick.c Usart.c Sim800.c Gpio.c Gstar.c Can.c Flash.c
  group user
    ../src/user/: Main.c Frame.c UsartTask.c
  group pro
    ../src/pro/: Tool.c
